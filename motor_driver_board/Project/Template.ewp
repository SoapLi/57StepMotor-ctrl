# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_IAR_Template
  ICCARM.CCIncludePath2: ..\LIB\inc; ..\Start; ..\System\delay; ..\System\usart; ..\System\sys; ..\User; ..\Driver\led; ..\Driver\stepmotor
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration C8T6 Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_IAR_Template
  ICCARM.CCIncludePath2: ..\LIB\inc; ..\Start; ..\System\delay; ..\System\usart; ..\System\sys; ..\User; ..\Driver\led
  group Driver
    ../Driver/stepmotor/: driver.c driver.h
    ../Driver/led/: led.c led.h
  group LIB
    ../LIB/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Start
    ../CMSIS/: startup_stm32f10x_hd.s
    ../Start/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group System/delay
    ../System/delay/: delay.c delay.h
  group System/sys
    ../System/sys/: sys.c sys.h
  group System/usart
    ../System/usart/: usart.c usart.h
  group User
    ../User/: main.c main.h
